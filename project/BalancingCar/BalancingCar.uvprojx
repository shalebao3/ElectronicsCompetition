# Keil uVision project BalancingCar.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BalancingCar +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=2
  c define: STM32F10X_MD
  c include: .\Start;.\USer;.\App;.\Common;.\Driver;.\Interface;.\Mid\FreeRTOS;.\Mid\FreeRTOS\include;.\Mid\FreeRTOS\Portable
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./USer/: main.c
  group Driver
    ./Driver/: DRIVER_TIM.c
  group Interface
    ./Interface/: INTERFACE_TB6612.c
  group Mid/FreeRTOS
    ./Mid/FreeRTOS/: FreeRTOSConfig.h
  group Mid/FreeRTOS/Source
    ./Mid/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Mid/FreeRTOS/portable
    ./Mid/FreeRTOS/Portable/: heap_4.c port.c
